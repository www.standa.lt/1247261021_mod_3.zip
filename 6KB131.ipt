# Autodesk Inventor part: 6KB131
## iProperties
Created: 2008-09
Part Number: 6KB131
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
